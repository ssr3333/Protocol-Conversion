# Keil uVision project RS485_Convertor.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8F2K64S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x07FF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: RS485_Convertor +hex
  c flags: Optimize=8 SizeSpeed=1
  group source
    ./source/: iap.c main.c sms310.c uart1.c uart2.c usr_gprs_730.c
  group include
    ./source/: pcb_protocol_convertor.h sms310.h iap.h stc8f.h uart1.h uart2.h usr_gprs_730.h wdt.h
